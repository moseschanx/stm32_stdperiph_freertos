# Keil uVision project apm32_stdPeriph_bare.uvprojx, settings and files
target Main (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F103TB Geehy
  pack: Geehy.APM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_stdperiph_bare
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,DEBUG
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport;..\APM32F10x_StdPeriph_Driver\inc;..\Drivers;..;..\SEGGER_RTT;..\FreeRTOS\include;..\FreeRTOS;..\Drivers;..\USER;..\3rd-Party
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c bsp_init.c
  group Sys/Boot
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: SWO.C system_apm32f10x.c apm32f10x_it.c
    ../CMSIS/CM3/DeviceSupport/: startup_apm32f10x_md.s
  group SEGGER_RTT
    ../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group 3rd-Party-Libs
    ../3rd-Party/: ftos.c
  group StdPeriph Drivers
    ../APM32F10x_StdPeriph_Driver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
software components: Compiler:I/O:STDOUT 1.2.0
